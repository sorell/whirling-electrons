# Repository sorell/whirling-electrons (continued)

## KiCad design arduino-nano-breakout-1/arduino-nano-breakout-1/arduino-nano-breakout-1.kicad_pcb (continued)

Board: 2 copper layers, 7.0 x 7.0 mm, 4 parts (0 on the bottom side), 10 nets.

## Commit log (part)

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2018-11-21 Arduino nano breakout 1
2018-11-21 power lines
2018-11-22 move
2018-11-22 final piece?
2018-11-22 VDD filtering capacitors
2018-11-22 PJ-002A datasheet
2018-11-22 Add silks
2018-11-23 change power connector
2018-11-23 tweaks
2018-11-27 ground fill and vias
2018-11-27 tweak
2018-12-11 Arduino nano breakout 1. Infinity table arduino code.
2019-01-07 xmas lights
2019-01-08 Color transformation profile
2019-02-20 Add a few tea-timer project and a few READMEs.
2019-02-21 Tea timer pcb, datasheets
2019-02-21 Tea timer PCB finished.
2019-02-23 Add button debounce filter.
2019-03-01 Missing file
2019-03-15 Add bmp2arduino and implement picture drawing from data in tea-timer.ino
2019-03-19 Update SSD1331 library to 1.1.0 and fix broken API changes.
2019-03-21 Add images for tea timer
2019-03-22 Tea timer animations done. Fix bmp converter reading uneven rows.
2019-03-22 Rename tea-timer-bmp-converter to bmp2arduino
2019-03-22 Remove converted image .c files in tea-timer: arduino seems to try to compile them.
2019-03-23 Pcb-tea-timer: fix piezo buzzer driving with a mosfet.
2019-03-24 Tea timer complete. Maybe to add more songs in the future..?
2019-03-24 Emphasize shadow in teacup.
2019-03-24 Add motd to tea timer and fix bmp 4byte aligning in bmp2arduino.
2019-03-27 Tea-timer: first upButton sets the time to 2:30
2019-03-27 Tea-timer: add Amelie Waltz and Game of Thrones theme.
2019-03-28 Fix line endings
2019-03-28 Tea-timer: move songs to progmem.
2019-04-12 Tea-timer: fix some comments, remove amelie's intro, constify some code.
2019-04-12 Tea-timer: introduce song list. Implement fading texts.
2019-09-20 Add voltage-sense project. Still preliminary.
2019-09-20 Pcb-tea-timer: add capacitor to support vcc against drops
2019-10-23 Clarify directory naming
2019-12-06 Add advent calendar sw and schematic.
2020-11-07 Add parking-timer-pcb, with RDA5807M symbol and footprint.
2020-11-08 Printed FM antenna design, castellation footprint for RDA5807M, RF filter.
2020-11-13 Add parking-timer-sw with build system and one tiny test app
2020-11-13 Add display connector, STM8L101F3
2020-11-13 Purge gitignored files from parking-timer-pcb
2020-11-14 Parking-timer-pcb: footprint for ER-EPM029-1, LIS3DSH module. Rework placement.
2020-11-15 Parking-timer-pcb: add BatteryHolder footprint, move MCU.
2020-11-17 Parking-timer-pcb: Fix ER-EPM029 footprint holes, add ADS1220 and a bazillion of other layout changes.
2020-11-19 parking-timer-pcb: Add solar cell connection, update STM8L101F3 symbol and footprint from ST. Fix DRC errors.
2020-11-20 Parking-timer-pcg: Add debug GND pin. Add comments and reorganize a bit.
2021-03-21 Modify gitignore for Kicad completeness. Remove parking-timer-sw (and move to another repo: mcu-galore). Add Adruino test projects for ER-ERM029 and RDA5807m.
2022-01-04 Create preliminary VirtualLedArray (final name pending)
2022-01-04 Templatize VirtualLedArray (name still pending)
2022-01-06 rename to LedUtils.h
2022-01-06 Refactor array
2022-01-06 LoopingMultiArray needs iterators
2022-01-18 utils in place. simple color shifting train
2022-01-20 Doc and improve utility classes.
2022-01-21 Split to files
2022-01-22 testing
2022-01-22 Add infinity-table-pcb project
2022-01-22 Add 74LVC8T245.lib
2022-01-22 forgot to save work
2022-01-23 wip infinity-table-pcb
2022-02-06 pcb first version done, but need to rework a bit
2022-02-06 pcb ver 2 done. Maybe potentiometer footprint needs to be checked
2022-02-15 Flip pcb design
2022-02-22 add silk
2022-02-24 power supply on the right, led connector on the left. idk
2022-02-26 pcb done again
2022-02-26 holes and texts
2022-02-26 moar holes
2022-03-23 Infinity-table-pcb v2
    Infinity table PCB with two buttons and a potentiometer.
    Placeholder for a txs0108 level shifter.
2022-03-23 Infinity-table-pcb v2 ordered gerbers and drill files.
2022-03-30 add pcb proj
2022-03-30 add mega symbols
2022-03-31 Fets, connectors, stuff. Their footprints. Horrible placement evaluation.
2022-04-03 update bom
2022-04-17 Infinity-table-sw: add 3 modes
2022-05-29 Sw for testing fet connection
2022-06-18 Psu, hierachical pages for fet driver
2022-06-18 DCDC from adj to 5V
2022-07-01 initial pcb placement and routing tests
2022-07-04 psu layout
2022-07-12 replace 5V side, via galore, lots of ground areas checked, rest of the signals places
2022-07-16 Vias galore
2022-07-22 Pull-up resistors. Some sw work.
2022-08-08 vias
2022-08-08 Change to 4 layer pcb. Routing leds done.
2022-08-09 minor tweaks to routing
2022-08-09 PSU, again.. Stitching. Moved arduino nano.
2022-09-11 Stairway to heaven sw timing tests
2022-10-22 Fix led data port
2022-10-22 Add CA6V potentiometer footprint. Mounting holes.
2022-10-23 Silks, small mods
2022-10-23 Add sensor drawing
2022-10-30 Add terminal for sensors
2022-10-30 Final touches
2022-10-30 Stairway to heaven PCB
2022-10-30 Stairway to heaven gerbers. Ordered.
2022-11-30 Fix fet pullups to pulldowns
2022-12-06 Organize footprints and symbols
2022-12-28 Add pdf prints for infinity-table, advent-calendar and stairway-to-heaven.
