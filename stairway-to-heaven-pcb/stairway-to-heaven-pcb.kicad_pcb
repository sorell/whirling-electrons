# Repository sorell/whirling-electrons

File README.md:

PCB files and SW (mainly) for arduino
=====================================

Advent calendar
---------------
Pushing a button gives a random led from 4x6 matrix. Non-volatile state saving.

Bmp2arduino
-----------
Utility for converting a BMP to C code.

Infinity table
--------------
Lightshow for adressable RGB leds.

Tea timer
---------
Tea timer with I2C display and buzzer. Simple animations and a few songs, all in C.

Xmas lights
-----------
Like infinity table, different show.

## KiCad design stairway-to-heaven-pcb/stairway-to-heaven-pcb.kicad_pcb

Board: 4 copper layers, 99.8 x 97.3 mm, 115 parts (42 on the bottom side), 93 nets.

Parts:
A1: Arduino_Nano_v2.x; Arduino_Nano
C1: 47uF; C_Elec_6.3x5.8
C2, C4: 100uF; C_Elec_8x6.2
C3, C5, C6: 10uF; C_1206_3216Metric
D1: DO-214AC; D_SMA
H1, H2, H3: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14: Conn_01x04_Male; ScrewTerminal-5_08
J15: PJ-063AH; CUI_PJ-063AH
J16: Conn_01x06_Male; ScrewTerminal-5_08-6
L1: 100uH; L_10.4x10.4_H4.8
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32, Q33, Q34, Q35, Q36, Q37, Q38, Q39, Q40, Q41, Q42: FDN337N; ON_Semi-527AG-01-12_2008-O-IPC_B
R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45: 50k; R_0805_2012Metric
RV100k1: R_Potentiometer_Trim; CA6V-NoMidHole
U1: MEGA_PRO_EMBED_CH340G_{slash}_ATMEGA2560; MODULE_MEGA_PRO_EMBED_CH340G___ATMEGA2560
U2: LM2575T-5.0

Connections:
+5V: A1.27 (+5V), C2.1, C4.1, C5.1, C6.1, J16.3, L1.2, RV100k1.1, U1.5V_1 (5V), U1.5V_2 (5V), U1.5V_3 (5V), U2.4 (FB)
+12V: C1.1, C3.2, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, U2.1 (VIN)
/LED1B_EN: Q3.1 (G), R6.2, U1.D8
/LED1G_EN: Q1.1 (G), R4.1, U1.D10
/LED1R_EN: Q2.1 (G), R5.1, U1.D11
/LED2B_EN: A1.19 (A0), Q9.1 (G), R12.2, U1.D2
/LED2G_EN: A1.21 (A2), Q7.1 (G), R10.1, U1.D4
/LED2R_EN: A1.20 (A1), Q8.1 (G), R11.1, U1.D3
/LED3B_EN: Q6.1 (G), R9.2, U1.D13
/LED3G_EN: Q4.1 (G), R7.1, U1.D15
/LED3R_EN: Q5.1 (G), R8.1, U1.D14
/LED4B_EN: A1.22 (A3), Q12.1 (G), R15.2, U1.D6
/LED4G_EN: A1.24 (A5), Q10.1 (G), R13.1, U1.D9
/LED4R_EN: A1.23 (A4), Q11.1 (G), R14.1, U1.D7
/LED5B_EN: Q15.1 (G), R18.2, U1.D16
/LED5G_EN: Q13.1 (G), R16.1, U1.D18
/LED5R_EN: Q14.1 (G), R17.1, U1.D17
/LED6B_EN: Q18.1 (G), R21.2, U1.D20
/LED6G_EN: Q16.1 (G), R19.1, U1.D22
/LED6R_EN: Q17.1 (G), R20.1, U1.D21
/LED7B_EN: Q21.1 (G), R24.2, U1.D26
/LED7G_EN: Q19.1 (G), R22.1, U1.D31
/LED7R_EN: Q20.1 (G), R23.1, U1.D29
/LED8B_EN: A1.8 (D5), Q24.1 (G), R27.2, U1.A13
/LED8G_EN: A1.10 (D7), Q22.1 (G), R25.1, U1.A9
/LED8R_EN: A1.9 (D6), Q23.1 (G), R26.1, U1.A11
/LED9B_EN: A1.14 (D11), Q27.1 (G), R30.2, U1.A2
/LED9G_EN: A1.15 (D12), Q25.1 (G), R28.1, U1.A1
/LED9R_EN: A1.16 (D13), Q26.1 (G), R29.1, U1.A0
/LED10B_EN: A1.5 (D2), Q30.1 (G), R33.2, U1.D32
/LED10G_EN: A1.7 (D4), Q28.1 (G), R31.1, U1.A14
/LED10R_EN: A1.6 (D3), Q29.1 (G), R32.1, U1.D33
/LED11B_EN: A1.11 (D8), Q33.1 (G), R36.2, U1.A7
/LED11G_EN: A1.13 (D10), Q31.1 (G), R34.1, U1.A4
/LED11R_EN: A1.12 (D9), Q32.1 (G), R35.1, U1.A5
/LED12B_EN: Q36.1 (G), R39.2, U1.D37
/LED12G_EN: Q34.1 (G), R37.1, U1.D35
/LED12R_EN: Q35.1 (G), R38.1, U1.D34
/LED13B_EN: Q39.1 (G), R42.2, U1.D40
/LED13G_EN: Q37.1 (G), R40.1, U1.D39
/LED13R_EN: Q38.1 (G), R41.1, U1.D38
/LED14B_EN: Q42.1 (G), R45.2, U1.D51
/LED14G_EN: Q40.1 (G), R43.1, U1.D49
/LED14R_EN: Q41.1 (G), R44.1, U1.D48
/POT1: RV100k1.2, U1.A15
/SENSOR1: J16.1, U1.D52
/SENSOR2: J16.2, U1.D53
/SENSOR3: A1.26 (A7), J16.5, U1.D30
/SENSOR4: A1.25 (A6), J16.6, U1.D28
GND: A1.4 (GND), A1.29 (GND), C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, D1.2 (A), H1.1, H2.1, H3.1, J15.2, J15.S1 (SHIELD), J15.S2 (SHIELD), J16.4, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), Q9.3 (S), Q10.3 (S), Q11.3 (S), Q12.3 (S), Q13.3 (S), Q14.3 (S), Q15.3 (S), Q16.3 (S), Q17.3 (S), Q18.3 (S), Q19.3 (S), Q20.3 (S), Q21.3 (S), Q22.3 (S), Q23.3 (S), Q24.3 (S), Q25.3 (S), Q26.3 (S), Q27.3 (S), Q28.3 (S), Q29.3 (S), Q30.3 (S), Q31.3 (S), Q32.3 (S), Q33.3 (S), Q34.3 (S), Q35.3 (S), Q36.3 (S), Q37.3 (S), Q38.3 (S), Q39.3 (S), Q40.3 (S), Q41.3 (S), Q42.3 (S), R4.2, R5.2, R6.1, R7.2, R8.2, R9.1, R10.2, R11.2, R12.1, R13.2, R14.2, R15.1, R16.2, R17.2, R18.1, R19.2, R20.2, R21.1, R22.2, R23.2, R24.1, R25.2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
unnamed: D1.1 (K), L1.1, U2.2 (OUT)
unnamed: J1.2, Q1.2 (D)
unnamed: J1.3, Q2.2 (D)
unnamed: J1.4, Q3.2 (D)
unnamed: J2.2, Q4.2 (D)
unnamed: J2.3, Q5.2 (D)
unnamed: J2.4, Q6.2 (D)
unnamed: J3.2, Q7.2 (D)
unnamed: J3.3, Q8.2 (D)
unnamed: J3.4, Q9.2 (D)
unnamed: J4.2, Q10.2 (D)
unnamed: J4.3, Q11.2 (D)
unnamed: J4.4, Q12.2 (D)
unnamed: J5.2, Q13.2 (D)
unnamed: J5.3, Q14.2 (D)
unnamed: J5.4, Q15.2 (D)
unnamed: J6.2, Q16.2 (D)
unnamed: J6.3, Q17.2 (D)
unnamed: J6.4, Q18.2 (D)
unnamed: J7.2, Q19.2 (D)
unnamed: J7.3, Q20.2 (D)
unnamed: J7.4, Q21.2 (D)
unnamed: J8.2, Q22.2 (D)
unnamed: J8.3, Q23.2 (D)
unnamed: J8.4, Q24.2 (D)
unnamed: J9.2, Q25.2 (D)
unnamed: J9.3, Q26.2 (D)
unnamed: J9.4, Q27.2 (D)
unnamed: J10.2, Q28.2 (D)
unnamed: J10.3, Q29.2 (D)
unnamed: J10.4, Q30.2 (D)
unnamed: J11.2, Q31.2 (D)
unnamed: J11.3, Q32.2 (D)
unnamed: J11.4, Q33.2 (D)
unnamed: J12.2, Q34.2 (D)
unnamed: J12.3, Q35.2 (D)
unnamed: J12.4, Q36.2 (D)
unnamed: J13.2, Q37.2 (D)
unnamed: J13.3, Q38.2 (D)
unnamed: J13.4, Q39.2 (D)
unnamed: J14.2, Q40.2 (D)
unnamed: J14.3, Q41.2 (D)
unnamed: J14.4, Q42.2 (D)

## KiCad design infinity-table-pcb/infinity-table-pcb.kicad_pcb

File infinity-table-pcb/README.md:

# PCB for the infinity-table project

Drive RGB leds with Arduino.

## Components

### Arduino Nano v2 or v3

### Barrel jack
Takes 8 ampers. Talk about oversizing.
https://www.digikey.fi/product-detail/en/cui-inc/PJ-063AH/CP-063AH-ND/2161208

## Future plans

Connect with Raspberry Pi to let the leds react with music.

### 74LVC8T245
Level shifter for future testing connection Arduino with Raspberry Pi
How to connect in [Adafruit page](https://www.adafruit.com/product/735)

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C3: 0,1uF; C_0805_2012Metric
C4, C5: 1nF; C_0805_2012Metric
H1, H2: MountingHole_Pad; MountingHole_4.3mm_M4_Pad
H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: PJ-063AH; CUI_PJ-063AH
J2: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical
R1: R; R_0805_2012Metric
RV1: R_Potentiometer; Potentiometer Pads
SW1, SW2: SW_Push_Dual; Push Button 12x12mm
U1: TXS0108EPW; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+5V: A1.27 (+5V), C1.2, J1.1, J2.4, RV1.1, U1.19 (VCCB)
GND: A1.4 (GND), A1.29 (GND), C1.1, C3.2, C4.1, C5.2, H1.1, H2.1, J1.2, J1.S1 (SHIELD), J1.S2 (SHIELD), J2.1, J2.2, J3.1, R1.2, RV1.3, SW1.2, SW1.4, SW2.2, SW2.4, U1.11 (GND)
unnamed: A1.5 (D2), J2.3
unnamed: A1.9 (D6), U1.20 (B1)
unnamed: A1.10 (D7), U1.18 (B2)
unnamed: A1.11 (D8), U1.17 (B3)
unnamed: A1.12 (D9), U1.16 (B4)
unnamed: A1.13 (D10), U1.15 (B5)
unnamed: A1.14 (D11), U1.14 (B6)
unnamed: A1.15 (D12), U1.13 (B7)
unnamed: A1.16 (D13), U1.12 (B8)
unnamed: A1.26 (A7), RV1.2
unnamed: C3.1, J3.10, R1.1, U1.2 (VCCA), U1.10 (OE)
unnamed: J3.2, U1.9 (A8)
unnamed: J3.3, U1.8 (A7)
unnamed: J3.4, U1.7 (A6)
unnamed: J3.5, U1.6 (A5)
unnamed: J3.6, U1.5 (A4)
unnamed: J3.7, U1.4 (A3)
unnamed: J3.8, U1.3 (A2)
unnamed: J3.9, U1.1 (A1)
SW1: A1.6 (D3), C4.2, SW1.3
SW2: A1.7 (D4), C5.1, SW2.3

Notes on the sheet:
LED connector
Level shifter

Board: 2 copper layers, 87.6 x 34.8 mm, 17 parts (8 on the bottom side), 23 nets.

## KiCad design parking-timer-pcb/parking-timer.kicad_pcb

Parts:
AE1: Antenna; FM-printed-antenna
C1: 82pF; C_0805_2012Metric
C2: 68pF; C_0805_2012Metric
C3, C4, C5, C7, C8: 100nF; C_0805_2012Metric
C6: 1uF; C_0805_2012Metric
C9: 1F 5V5; BatteryHolder
D1: D; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_02x04_Odd_Even; ER-EPM029-1_Module
J3, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_01x11; LIS3DSH_Module
J7: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
L1: 1.5nH; L_0805_2012Metric
L2: 100nH; L_0805_2012Metric
L3: 68nH; L_0805_2012Metric
L4, L5: L_Core_Ferrite; R_0805_2012Metric
Q1: AO3401A; SOT-23
R1, R2, R3: 47k; R_0805_2012Metric
R4, R5: 4k7; R_0805_2012Metric
U1: RDA5807M_Module; RDA5807M-through-hole
U2: STM8L101F3P6TR
U3: ADS1220xPW; TSSOP-16_4.4x5mm_P0.65mm

Connections:
ACCE_CS: J4.6, U2.6 (PA3)
ACCE_INT1: J4.7, U2.5 (PA2)
ADC_CS: U2.12 (PB2), U3.2 (~CS)
ADC_DRDY: U2.10 (PB0), U3.14 (~DRDY)
DISP_BUSY: J2.8, U2.13 (PB3)
DISP_CS: J2.5, U2.14 (PB4)
DISP_DC: J2.6, U2.20 (PC2)
DISP_RST: J2.7, U2.2 (PC4)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C9.2, J1.1, J2.2, J3.3, J4.2, J4.9, J4.11, J5.1, J6.1, J6.2, J7.1, L3.2, L4.2, L5.2, R3.2, U1.6 (GND), U2.7 (VSS), U3.3 (CLK), U3.4 (DGND)
GNDA: C8.2, L4.1, L5.1, U3.5 (AVSS)
I2C_SDA: R4.2, U1.1 (SDA), U2.18 (PC0)
I2C_SDC: R5.2, U1.2 (SCK), U2.19 (PC1)
NRST: C4.1, J1.2, J3.4, U2.4 (NRST/PA1)
unnamed: AE1.1, L1.1, L3.1
unnamed: C1.2, L1.2, L2.1
unnamed: C2.2, L2.2, U1.10 (ANT)
unnamed: D1.2 (A), J5.2
unnamed: Q1.2 (S), R2.1
unnamed: R2.2, R3.1, U3.11 (AIN0/REFP1)
SPI_MISO: J4.5, U2.17 (PB7), U3.15 (DOUT/~DRDY)
SPI_MOSI: J2.3, J4.4, U2.16 (PB6), U3.16 (DIN)
SPI_SCK: J2.4, J4.3, U2.15 (PB5), U3.1 (SCLK)
SWIM: J3.2, U2.3 (PA0)
UART_TX: J6.3, U2.1 (PC3)
VDD: C3.2, C5.1, C6.1, C7.1, C8.1, C9.1, D1.1 (K), J2.1, J3.1, J4.1, Q1.3 (D), R1.1, R4.1, R5.1, U1.5 (VDD), U2.8 (VDD), U3.12 (AVDD), U3.13 (DVDD)
VMEAS_EN: Q1.1 (G), R1.2, U2.11 (PB1)

Notes on the sheet:
Solar cell: 4V 60mA 0V7 diode: VDD up to 3V3
MCU reset jumper
Programming interface
ADC for VDD meaduring
LIS3DSH 3D accelerometer
RM radio
Debug uart, TTL
Place close to pin
ER-EPM029-1 B/W E-Ink 2.9" display, 296 x 128

Board: 2 copper layers, 92.9 x 95.3 mm, 32 parts (3 on the bottom side), 26 nets.

## KiCad design pcb-tea-timer/pcb-tea-timer.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
BZ1: Buzzer; Round Piezo 1
C1, C2: 1nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 1000uF; CP_Radial_D7.5mm_P2.50mm
GND1: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
J1: Conn_01x07_Female; PinHeader_1x07_P2.54mm_Vertical
J2: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
Q1: 2N7002; SOT-23
R1: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW2: SW_Push_Dual; Push Button 12x12mm

Connections:
+3V3: A1.17 (3V3), J1.2
+5V: A1.27 (+5V), BZ1.1 (-), C3.1, R2.2
GND: A1.4 (GND), A1.29 (GND), C1.2, C2.2, C3.2, GND1.1, GND1.2, J1.1, J2.1, J2.2, Q1.2 (S), R1.1, SW1.2, SW1.4, SW2.2, SW2.4
unnamed: A1.5 (D2), C1.1, SW1.1, SW1.3
unnamed: A1.6 (D3), C2.1, SW2.1, SW2.3
unnamed: A1.9 (D6), Q1.1 (G), R1.2
unnamed: A1.11 (D8), J1.6
unnamed: A1.12 (D9), J1.5
unnamed: A1.13 (D10), J1.7
unnamed: A1.14 (D11), J1.4
unnamed: A1.16 (D13), J1.3
unnamed: BZ1.2 (+), Q1.3 (D), R2.1

Notes on the sheet:
SSD1331 OLED
Physical support for the display
Debug GND

Board: 2 copper layers, 36.1 x 69.2 mm, 13 parts (7 on the bottom side), 12 nets.

## KiCad design arduino-nano-breakout-1/arduino-nano-breakout-1.kicad_pcb

Board: 2 copper layers, 40.0 x 48.9 mm, 10 parts (0 on the bottom side), 20 nets.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2: 100nF; C_0805_2012Metric
IO2, IO3, IO5, IO6: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
J1: PJ-063AH; CUI_PJ-063AH-1
J2: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical

Connections:
D0: A1.2, J3.10
D1: A1.1, J3.9
D2: A1.5, IO2.3
D3: A1.6, IO3.3
D5: A1.8, IO5.3
D6: A1.9, IO6.3
D9: A1.12, J3.4
D10: A1.13, J3.3
GND: A1.4, A1.29, C1.2, C2.2, J1.2, J1.S1, J1.S2, J2.1, J3.2
unnamed: A1.21, IO2.1
unnamed: A1.22, IO3.1
unnamed: A1.24, IO5.1
unnamed: A1.25, IO6.1
unnamed: A1.27, C2.1, J2.5
unnamed: A1.30, C1.1, J2.3
unnamed: IO2.2, J3.8
unnamed: IO3.2, J3.7
unnamed: IO5.2, J3.6
unnamed: IO6.2, J3.5
unnamed: J1.1, J2.4, J3.1

## KiCad design arduino-nano-breakout-1/arduino-nano-breakout-1/arduino-nano-breakout-1.kicad_pcb

Schematic: arduino-nano-breakout-1.sch

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
J1: PJ-002A; CUI_PJ-002A
J2: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical

Connections:
GND: A1.4 (GND), A1.29 (GND), J1.2, J4.1
IO2: A1.5 (D2), J4.3
IO3: A1.6 (D3), J4.4
IO5: A1.8 (D5), J4.5
IO6: A1.9 (D6), J4.6
IO9: A1.12 (D9), J4.7
IO10: A1.13 (D10), J4.8
unnamed: A1.27 (+5V), J2.1, J4.2
unnamed: A1.30 (VIN), J2.3
unnamed: J1.1, J2.2

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
Copyright 2021 Accelerated Designs. All rights reserved.
